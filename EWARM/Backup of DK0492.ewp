# IAR project Backup of DK0492.ewp, settings and files
configuration DK0492 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R5ZI ST STM32L4R5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_MICRIUM; USE_HAL_DRIVER; STM32L4R5xx; DEBUG
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\BSP\OS3; ..\Drivers\Devices; ..\Drivers\Display; ..\Micrium\uC_CPU Core\Micrium\Software\uC-CPU; ..\Micrium\uC_CPU Core\Micrium\Software\uC-CPU\ARM-Cortex-M\ARMv7-M\IAR; ..\Micrium\uC_CPU Core\Micrium\Software\uC-CPU\Cfg\Template; ..\Micrium\uC_LIB Core\Micrium\Software\uC-LIB; ..\Micrium\uC_LIB Core\Micrium\Software\uC-LIB\Cfg\Template; ..\Micrium\uC_OS-III port for the ARM Cortex-M\Micrium\Software\uCOS-III\Source; ..\Micrium\uC_OS-III port for the ARM Cortex-M\Micrium\Software\uCOS-III\Cfg\Template; ..\Micrium\uC_OS-III port for the ARM Cortex-M\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\Middlewares\ST\STemWin\CurrentConfig; ..\Middlewares\ST\STemWin\inc; ..\Application\Comms; ..\Application\DTask; ..\Application\DUCI; ..\Application\ErrorHandler; ..\Application\Instrument; ..\Application\KeyHandler; ..\Application\Main; ..\Application\Sensor; ..\Application\Synchronisation; ..\Application\UI; ..\Bitmaps; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: DK0492.hex
  ILINK.IlinkOutputFile: DK0492.out
  ILINK.IlinkIcfFile: stm32l4r5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Comms
    ../Application/Comms/: DComms.cpp DComms.h DCommsFsm.cpp DCommsFsm.h DCommsFsmSerial.cpp DCommsFsmSerial.h DCommsFsmUsb.cpp DCommsFsmUsb.h DCommsSerial.cpp DCommsSerial.h DCommsState.cpp DCommsState.h DCommsStateDevDiscovery.cpp DCommsStateDevDiscovery.h DCommsStateExternal.cpp DCommsStateExternal.h DCommsStateLocal.cpp DCommsStateLocal.h DCommsStateProdTest.cpp DCommsStateProdTest.h DCommsStateRemote.cpp DCommsStateRemote.h DCommsStateRemoteSerial.cpp DCommsStateRemoteSerial.h DCommsStateRemoteUsb.cpp DCommsStateRemoteUsb.h DCommsStateUsbIdle.cpp DCommsStateUsbIdle.h DCommsUsb.cpp DCommsUsb.h
  group Application/DTask
    ../Application/DTask/: DTask.cpp DTask.h
  group Application/DUCI
    ../Application/DUCI/: DParse.cpp DParse.h DParseMaster.cpp DParseMaster.h DParseMasterSlave.cpp DParseMasterSlave.h DParseSlave.cpp DParseSlave.h
  group Application/ErrorHandler
    ../Application/ErrorHandler/: DErrorHandler.cpp DErrorHandler.h
  group Application/EWARM
    ./: startup_stm32l4r5xx.s
  group Application/Instrument
    ../Application/Instrument/: DInstrument.cpp DInstrument.h
  group Application/KeyHandler
    ../Application/KeyHandler/: DKeyHandler.cpp DKeyHandler.h
  group Application/Main
    ../Application/Main/: Application.cpp Application.h DDPI610E.cpp DDPI610E.h misra.h Types.h Utilities.c Utilities.h
  group Application/Synchronisation
    ../Application/Synchronisation/: DLock.cpp DLock.h
  group Application/UI
    ../Application/UI/: BootloaderDemo.c BootloaderDemo.h DDisplay.cpp DDisplay.h digits5x9.h digits8x16.h DScreen.cpp DScreen.h DScreenDummy.cpp DScreenDummy.h DScreenEmcTest.cpp DScreenEmcTest.h DUserInterface.cpp DUserInterface.h font5x7.h font7x10.h font_digits.h SMLCD.c SMLCD.h
  group Application/User
    ../Src/: main.c MainApp.c os_app_hooks.c stm32l4xx_hal_msp.c stm32l4xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Drivers/BSP/OS3
    ../Drivers/BSP/OS3/: bsp_cpu.c bsp_os.c bsp_os.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/Devices
    ../Drivers/Devices/: DDevice.cpp DDevice.h DDeviceSerial.cpp DDeviceSerial.h DDeviceSerialRS485.cpp DDeviceSerialRS485.h DDeviceSerialUSB.cpp DDeviceSerialUSB.h uart.c uart.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Micrium/Software/TLS
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/TLS/IAR/: os_tls.c
  group Micrium/Software/uC-CPU/ARM-Cortex-M4
    ../Micrium/uC_CPU Core/Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../Micrium/uC_CPU Core/Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR
    ../Micrium/uC_CPU Core/Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/IAR/: cpu.h cpu_a.asm
  group Micrium/Software/uC-LIB/ARM-Cortex-M4
    ../Micrium/uC_LIB Core/Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/Software/uC-LIB/ARM-Cortex-M4/IAR
    ../Micrium/uC_LIB Core/Micrium/Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
  group Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm
  group Micrium/Software/uCOS-III/Source
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
