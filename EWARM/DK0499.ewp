# IAR project DK0499.ewp, settings and files
configuration DK0499 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R5ZI ST STM32L4R5ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_MICRIUM; USE_HAL_DRIVER; STM32L4R5xx; DEBUG
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\BSP\OS3; ..\Drivers\Devices; ..\Drivers\Display; ..\Micrium\uC_CPU Core\Micrium\Software\uC-CPU; ..\Micrium\uC_CPU Core\Micrium\Software\uC-CPU\ARM-Cortex-M\ARMv7-M\IAR; ..\Micrium\uC_CPU Core\Micrium\Software\uC-CPU\Cfg\Template; ..\Micrium\uC_LIB Core\Micrium\Software\uC-LIB; ..\Micrium\uC_LIB Core\Micrium\Software\uC-LIB\Cfg\Template; ..\Micrium\uC_OS-III port for the ARM Cortex-M\Micrium\Software\uCOS-III\Source; ..\Micrium\uC_OS-III port for the ARM Cortex-M\Micrium\Software\uCOS-III\Cfg\Template; ..\Micrium\uC_OS-III port for the ARM Cortex-M\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\Application\Comms; ..\Application\DTask; ..\Application\DUCI; ..\Application\ErrorHandler; ..\Application\Instrument; ..\Application\KeyHandler; ..\Application\Main; ..\Application\Sensor; ..\Application\Synchronisation; ..\Application\UI; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\Application\Channel; ..\Application\Function; ..\Application\Slot; ..\Application\Sensor; ..\Application\Range; ..\Application\Process; ..\Application\Data; ..\Application\Persistent; ..\Application\RTC; ..\Application\Gpio; ../Drivers/Peripherals\EEPROM; ..\Drivers\DevicesUART; ..\Application\OWI; C:\Users\312005216\Box Sync\GitHub\DK0499_POC\Drivers\Devices\UART; ..\Src; ..\Application\DBattery; ..\Application\PowerManager
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: DK0499.hex
  ILINK.IlinkOutputFile: DK0499.out
  ILINK.IlinkIcfFile: stm32l4r5xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Application/Main/: DPV624.cpp
  group Application/Calibration
    ../Application/Data/: DCalibration.cpp DCalibration.h
  group Application/Comms
    ../Application/Comms/: DComms.cpp DComms.h DCommsFsm.cpp DCommsFsm.h DCommsFsmOwi.cpp DCommsFsmOwi.h DCommsFsmSerial.cpp DCommsFsmSerial.h DCommsFsmUsb.cpp DCommsFsmUsb.h DCommsOwi.cpp DCommsOwi.h DCommsSerial.cpp DCommsSerial.h DCommsState.cpp DCommsState.h DCommsStateDuci.cpp DCommsStateDuci.h DCommsStateLocal.cpp DCommsStateLocal.h DCommsStateOwi.cpp DCommsStateOwi.h DCommsStateOwiRead.cpp DCommsStateOwiRead.h DCommsStateOwiWrite.cpp DCommsStateOwiWrite.h DCommsStateProdTest.cpp DCommsStateProdTest.h DCommsStateRemote.cpp DCommsStateRemote.h DCommsStateUsbIdle.cpp DCommsStateUsbIdle.h DCommsUsb.cpp DCommsUsb.h
  group Application/DBattery
    ../Application/DBattery/: DBattery.cpp DBattery.h
  group Application/DPowerManager
    ../Application/PowerManager/: DPowerManager.cpp DPowerManager.h
  group Application/DTask
    ../Application/DTask/: DTask.cpp DTask.h
  group Application/DUCI
    ../Application/DUCI/: DParse.cpp DParse.h DParseMaster.cpp DParseMaster.h DParseMasterSlave.cpp DParseMasterSlave.h DParseSlave.cpp DParseSlave.h
  group Application/ErrorHandler
    ../Application/ErrorHandler/: DErrorHandler.cpp DErrorHandler.h
  group Application/EWARM
    ./: startup_stm32l4r5xx.s
  group Application/Function
    ../Application/Function/: DFunction.cpp DFunction.h DFunctionMeasure.cpp DFunctionMeasure.h DFunctionMeasureAndControl.cpp DFunctionMeasureAndControl.h
  group Application/Instrument
    ../Application/Instrument/: DInstrument.cpp DInstrument.h
  group Application/KeyHandler
    ../Application/KeyHandler/: DKeyHandler.cpp DKeyHandler.h
  group Application/Main
    ../Application/Main/: Application.cpp Application.h crc.c crc.h DPV624.h memory.c memory.h misra.h Types.h Utilities.c Utilities.h
  group Application/OWI
    ../Application/OWI/: DOwiParse.cpp DOwiParse.h
  group Application/Persistent
    ../Application/Persistent/: DPersistent.cpp DPersistent.h PersistentCal.h PersistentConfig.h PersistentMaintenanceData.h PersistentSettings.h
  group Application/Range
    ../Application/Range/: DRange.cpp DRange.h
  group Application/RTC
    ../Application/RTC/: DRTC.cpp DRTC.h
  group Application/Sensor
    ../Application/Sensor/: DAmcSensorData.cpp DAmcSensorData.h DPressureCompensation.cpp DPressureCompensation.h DSensor.cpp DSensor.h DSensorChipBarometer.cpp DSensorChipBarometer.h DSensorDuci.cpp DSensorDuci.h DSensorDuciTerpsBarometer.cpp DSensorDuciTerpsBarometer.h DSensorExternal.cpp DSensorExternal.h DSensorOwi.cpp DSensorOwi.h DSensorOwiAmc.cpp DSensorOwiAmc.h DSensorPseudo.cpp DSensorPseudo.h
  group Application/Slot
    ../Application/Slot/: DSlot.cpp DSlot.h DSlotExternal.cpp DSlotExternal.h DSlotMeasureBarometer.cpp DSlotMeasureBarometer.h DSlotMeasurePressureExt.cpp DSlotMeasurePressureExt.h DSlotPseudo.cpp DSlotPseudo.h DSlotSwitch.cpp DSlotSwitch.h
  group Application/Synchronisation
    ../Application/Synchronisation/: DLock.cpp DLock.h
  group Application/UI
    ../Application/UI/: DUserInterface.cpp DUserInterface.h
  group Application/User
    ../Src/: i2c.c i2c.h main.c MainApp.c os_app_hooks.c stm32l4xx_hal_msp.c stm32l4xx_it.c uart.c uart.h usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
  group Drivers/BSP/OS3
    ../Drivers/BSP/OS3/: bsp_cpu.c bsp_os.c bsp_os.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/Devices
    ../Drivers/Devices/: DDevice.cpp DDevice.h DDeviceSerial.cpp DDeviceSerial.h DDeviceSerialOwiInterface1.cpp DDeviceSerialOwiInterface1.h DDeviceSerialOwiInterface2.cpp DDeviceSerialOwiInterface2.h DDeviceSerialRS485.cpp DDeviceSerialRS485.h DDeviceSerialUSB.cpp DDeviceSerialUSB.h
  group Drivers/Peripherals/EEPROM
    ../Drivers/Peripherals/EEPROM/: EEPROM.c EEPROM.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Micrium/Software/TLS
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/TLS/IAR/: os_tls.c
  group Micrium/Software/uC-CPU/ARM-Cortex-M4
    ../Micrium/uC_CPU Core/Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../Micrium/uC_CPU Core/Micrium/Software/uC-CPU/: cpu_cache.h cpu_core.c cpu_core.h cpu_def.h
  group Micrium/Software/uC-CPU/ARM-Cortex-M4/IAR
    ../Micrium/uC_CPU Core/Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/IAR/: cpu.h cpu_a.asm
  group Micrium/Software/uC-LIB/ARM-Cortex-M4
    ../Micrium/uC_LIB Core/Micrium/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/Software/uC-LIB/ARM-Cortex-M4/IAR
    ../Micrium/uC_LIB Core/Micrium/Software/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
  group Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm
  group Micrium/Software/uCOS-III/Source
    ../Micrium/uC_OS-III port for the ARM Cortex-M/Micrium/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_trace.h os_type.h os_var.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
